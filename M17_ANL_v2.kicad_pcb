# Repository sp5wwp/M17_ANL_v2

File README.md:

# M17_ANL_v2
New M17 hotspot/analyser, this time with ADF7021

## Schematic
Diagram was not tested yet.
However, schematic and PCB layout is still work in progress.
PCB design was put into production in 1 February 2020.
Testing will take aprox. 2 months.

## Technical details

M17_ANL_v2 is a radio modem designed especially to support interaction with existing M17 capable radio terminals & repeaters. It also means packet acquisition, for debugging cases or sniffing, just for fun idk.
However M17_ANL_v2 can be used to receive and transmit raw digital data - it's by design protocol agnostic. 

### Parameters

* Operating freqency range is 420MHz to 450MHz (M17 operates within amateur frequency band 430-440MHz) - after a few changes of RF elements values also another frequency bands
* Modulation schemes selectable - 2FSK, 3FSK, 4FSK, MSK and FM (for M17 - 4FSK)
* Output power level is set from -16dbm up to 10dbm (in 0.3125 dB steps)
* Data rate is set from 0.05 up to 25 kbps (for M17 - 9600 bps)
* IF filter bandwidth selectable - 12.5 kHz, 18.75 kHz, or 25 kHz
* Configuration, transmit and receive by AT commands - over USB-CDC
* All registers of ADF7021 also configurable by manual mode
* Additional 4 GPIOs - first pair can be used as I2C interface, second can be UART
* Four different colour LEDs - PWR, SYS, RX and TX - indicate the state of the device
* Programmable by SWD interface

MORE TODO

### Most important ICs used in project

* STM32F303CBT6 - MCU which controls data flow(PC <-> RF TRX), and radio parameters.
* ADF7021 - radio transceiver.

### Testpoints description

| TestPoint NO  | Description | Pin of STM32 | Pin of ADF7021 |
| ------------- | ------------- | ------------- | ------------- |
| TP1  | SPI_SCK  | PB13  | 28 |
| TP2  | SPI_MISO  | PB14  | 27 |
| TP3  | SPI_MOSI  | PB15  | 26 |
| TP4  | SPI_ENABLE  | PA8  | 25 |
| TP5  | RF_ENABLE  | PA9  | 24 |
| TP6  | DClk  | PA6  | 35 |
| TP7  | Data  | PA7  | 34 |
| TP8  | SWD  | PB0  | 33 |
| TP9  | RF_CLK  | PA5  | 36 |
| TP10  | AD  | PA2  | from Filter 1 |
| TP11  | MO  | PA3  | 37 |
| TP12  | DA  | PA4  | to Filter 2 |
| TP13  | FMDM  | to Filter 1  | 33 |
| TP14  | FMM  | from Filter 2  | 21 |

Filter 1 - used by ADC,
Filter 2 - used by DAC

MORE TODO

### Headers description

| Header  | Pin | Pin of STM32 | Use case |
| ------------- | ------------- | ------------- | ------------- |
| J4  | 1  | GND  | X |
| J4  | 2  | PB9  | GPIO, I2C_SDA |
| J4  | 3  | PB8  | GPIO, I2C_SCK |
| J4  | 4  | PB7  | GPIO, USART_RX |
| J4  | 5  | PB6  | GPIO, USART_TX |
| J4  | 6  | VCC  | X |
| ------------- | ------------- | ------------- | ------------- |
| J3  | 1  | NRST  | RST |
| J3  | 2  | GND  | X |
| J3  | 3  | PA13  | SWDIO |
| J3  | 4  | PA14  | SWCLK |
| J3  | 5  | VCC  | X |

## Control software

TODO

## KiCad design M17_ANL_v2.kicad_pcb

Parts:
C1, C3, C7, C9, C12, C13, C21, C31, C39, C40: 10n; C_0402_1005Metric
C2, C5, C8, C11, C32: 100n; C_0402_1005Metric
C4: 22p; C_0402_1005Metric
C6: 4,7u; C_1206_3216Metric
C10: 22n; C_0402_1005Metric
C14: 470p; C_0402_1005Metric
C15: 15n; C_0402_1005Metric
C16: 1n; C_0402_1005Metric
C17: 100n; C_1206_3216Metric
C18, C45: 100n; C_0805_2012Metric
C19: 10n; C_0805_2012Metric
C20: 220p; C_0402_1005Metric
C22, C25: 6,8p; C_0402_1005Metric
C23: 4,7p; C_0402_1005Metric
C24: 10p; C_0402_1005Metric
C26, C27, C28, C29, C30: 10n; C_0603_1608Metric
C33, C34, C35, C36, C37, C38: 4,7n; C_0402_1005Metric
C41, C42, C46: 1n; C_0603_1608Metric
C43, C44: 100n; C_0603_1608Metric
D1: TX; LED_0603_1608Metric
D2: RX; LED_0603_1608Metric
D3: SYS; LED_0603_1608Metric
D4: PWR; LED_0603_1608Metric
J1: USB_A; USB_A_CNCTech_1001-011-01101_Horizontal
J2: RF_PORT; SMA_Samtec_SMA-J-P-X-ST-EM1_EdgeMount
J3: PROG; PinHeader_1x05_P1.27mm_Vertical
J4: Conn_01x06; PinHeader_1x06_P1.27mm_Vertical
JP1: Boot0; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: Boot1; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 18n; L-0402CS
L2: 27n; L-0402CS
L3: 13n; L-0402CS
L4: 20n; L-0402CS
L5: 22n; L-0402CS
L6, L8: 10uH; L_0805_2012Metric
L7: 1uH; L_0805_2012Metric
R1, R2, R3, R4, R5, R6, R7, R16, R18, R19, R20, R21, R22, R23, R25, R26, R27: 1k; R_0402_1005Metric
R8: 3,9k; R_0402_1005Metric
R9: 3,6k; R_0402_1005Metric
R10: 1,1k; R_0402_1005Metric
R11: 560; R_0402_1005Metric
R12: 270; R_0402_1005Metric
R13, R14: 22; R_0402_1005Metric
R15: 1,3k; R_0402_1005Metric
R17: 10k; R_0402_1005Metric
R24: 100k; R_0402_1005Metric
R28, R29: 4,7k; R_0402_1005Metric
R30: 1k; R_0805_2012Metric
R31: 47k; R_0402_1005Metric
R32: 100; R_0402_1005Metric
RN1: R_Pack04; R_Array_Convex_4x0603
TP1: SCK; TestPoint_Pad_D1.0mm
TP2: MISO; TestPoint_Pad_D1.0mm
TP3: MOSI; TestPoint_Pad_D1.0mm
TP4: S_EN; TestPoint_Pad_D1.0mm
TP5: RF_EN; TestPoint_Pad_D1.0mm
TP6: DClk; TestPoint_Pad_D1.0mm
TP7: Data; TestPoint_Pad_D1.0mm
TP8: SWD; TestPoint_Pad_D1.0mm
TP9: RF_CLK; TestPoint_Pad_D1.0mm
TP10: AD; TestPoint_Pad_D1.0mm
TP11: MO; TestPoint_Pad_D1.0mm
TP12: DA; TestPoint_Pad_D1.0mm
TP13: FMDM; TestPoint_Pad_D1.0mm
TP14: FMM; TestPoint_Pad_D1.0mm
U1: STM32F303CBTx; LQFP-48_7x7mm_P0.5mm
U2: ADF7021; Manufacturer_Part_Number ADF7021-VBCPZ-RL; Mouser Part Number 584-ADF7021-VBCPZ-R
U3: AP1117-33; SOT-223-3_TabPin2
X1, X2: ASV-xxxMHz; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
ADC_IN: C33.2, R19.2, TP10.1, U1.12 (PA2)
BOOT0: JP1.2, U1.44 (BOOT0)
BOOT1: JP2.2, U1.20 (PB2)
CPOUT: C16.1, R11.2, R12.2, U2.42 (CPOUT)
DAC_OUT: C34.2, R20.2, TP12.1, U1.14 (PA4)
FMDemod: C39.1, R23.1, R25.1, R26.2, TP13.1
FMMod: C40.2, R24.1, TP14.1
GND: C1.2, C2.1, C3.1, C5.2, C6.2, C7.1, C8.1, C9.1, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C25.1, C26.1, C27.1, C28.2, C29.2, C30.1, C31.1, C32.2, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.4 (GND), J1.5 (Shield), J2.2 (Ext), J3.2, J4.1, JP1.3, JP2.3, R9.2, R10.2, R26.1, R30.2, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.5 (RFGND), U2.12 (GND4_1), U2.19 (GND4_2), U2.22 (GND4_3), U2.29 (GND2), U2.45 (GND), U2.47 (GND1), U2.49 (EP), U3.1 (GND), X1.2 (GND), X2.2 (GND); also elsewhere on the board
I2C_SCK: J4.3, R29.1, U1.45 (PB8)
I2C_SDA: J4.2, R28.1, U1.46 (PB9)
MO: R27.2, TP11.1, U1.13 (PA3)
MoDem_VCC: C3.2, C7.2, C9.2, C12.1, C13.2, C20.1, C21.1, C31.2, C41.1, C46.1, L3.2, L8.2, R25.2, R30.1, U2.3 (VDD1), U2.9 (VDD4), U2.32 (VDD2), U2.40 (VDD3), U2.43 (VDD), X1.1 (EN), X1.4 (Vdd)
unnamed: C2.2, U2.31 (CREG2)
unnamed: C4.2, U2.39 (OSC1)
unnamed: C5.1, U2.41 (CREG3)
unnamed: C8.2, R8.1
unnamed: C10.1, U2.48 (CVCO)
unnamed: C10.2, R8.2, U2.2 (CREG1)
unnamed: C11.1, U2.11 (CREG4)
unnamed: C14.1, R11.1, R32.2
unnamed: C15.1, R12.1
unnamed: C6.1, C17.1, L7.2, U3.3 (VI)
unnamed: C22.2, L2.1, U2.7 (~RFIN)
unnamed: C23.1, L2.2, U2.6 (RFIN)
unnamed: C23.2, C24.2, L4.1
unnamed: C24.1, L3.1, U2.4 (RFOUT)
unnamed: C25.2, L4.2, L5.1
unnamed: C35.2, R19.1, R21.2
unnamed: C36.2, R20.1, R22.2
unnamed: C37.2, R21.1, R23.2
unnamed: C38.2, R22.1, R24.2
unnamed: C39.2, R3.1, U2.33 (SWD)
unnamed: C40.1, R31.1
unnamed: C44.1, L6.1, U3.2 (VO)
unnamed: D1.2 (A), RN1.8 (R1.2)
unnamed: D2.2 (A), RN1.7 (R2.2)
unnamed: D3.2 (A), RN1.6 (R3.2)
unnamed: D4.2 (A), RN1.5 (R4.2)
unnamed: J1.2 (D-), R14.2
unnamed: J1.3 (D+), R13.2
unnamed: J2.1 (In), L5.2
unnamed: L1.1, U2.46 (L1)
unnamed: L1.2, U2.44 (L2)
unnamed: R1.1, U2.25 (SLE)
unnamed: R2.1, U2.26 (SDATA)
unnamed: R4.1, U2.27 (SREAD)
unnamed: R5.1, U2.28 (SCLK)
unnamed: R6.1, U2.34 (TXRXDATA)
unnamed: R7.1, U2.35 (TXRXCLK)
unnamed: R9.1, U2.10 (RSET)
unnamed: R10.1, U2.8 (RLNA)
unnamed: R16.1, U2.24 (CE)
unnamed: R18.1, U2.36 (CLKOUT)
unnamed: R27.1, U2.37 (MUXOUT)
PWR_LED: RN1.4 (R4.1), U1.38 (PA15)
RF_CLKOUT: R18.2, TP9.1, U1.15 (PA5)
RF_EN: R16.2, TP5.1, U1.30 (PA9)
RST_PIN: C32.1, J3.1, R17.1, U1.7 (NRST)
RX_LED: RN1.2 (R2.1), U1.40 (PB4)
SPI_CLK: R5.2, TP1.1, U1.26 (PB13)
SPI_EN: R1.2, TP4.1, U1.29 (PA8)
SPI_MISO: R4.2, TP2.1, U1.27 (PB14)
SPI_MOSI: R2.2, TP3.1, U1.28 (PB15)
SWCLK: J3.4, U1.37 (PA14)
SWDIO: J3.3, U1.34 (PA13)
SWD_Int: R3.2, TP8.1, U1.18 (PB0)
SYS_LED: RN1.3 (R3.1), U1.39 (PB3)
TCXO_MCU: U1.5 (PF0), X2.3 (OUT)
TCXO_RF: C4.1, X1.3 (OUT)
TX_LED: RN1.1 (R1.1), U1.41 (PB5)
TxRx_Clk: R7.2, TP6.1, U1.16 (PA6)
TxRx_Data: R6.2, TP7.1, U1.17 (PA7)
USART_RX: J4.4, U1.43 (PB7)
USART_TX: J4.5, U1.42 (PB6)
USB_DM: R14.1, U1.32 (PA11)
USB_DP: R13.1, R15.1, U1.33 (PA12)
VBUS: C45.1, J1.1 (VBUS), L7.1
VCC_MCU: C1.1, C18.1, C19.1, C26.2, C27.2, C28.1, C29.1, C30.2, C42.1, C43.1, J3.5, J4.6, JP1.1, JP2.1, L6.2, L8.1, R15.2, R17.2, R28.2, R29.2, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), X2.1 (EN), X2.4 (Vdd); also elsewhere on the board
VCO_IN: R31.2, R32.1, U2.1 (VCOIN)

Notes on the sheet:
RF Transceiver
RF Matching and Filtering
RF_TCXO
PLL Filter
Power converter
Power interconnect
Communication Controller
USB
MCU_TCXO
LED Diodes
SWDebug
Reset
BootSet
ADC Filtering
DAC Filtering
and voltage dividing
Unused Ports
R25 and R26 values will be defined after prototyping

Board: 2 copper layers, 63.2 x 19.6 mm, 117 parts (53 on the bottom side), 79 nets.

Other parts of the board:
C31#2: 10n; C_0603_1608Metric

Their connections:
GND: C31#2.1; also elsewhere on the board
VCC_MCU: C31#2.2; also elsewhere on the board

## Commit log

2019-12-29 Testing#1
2019-12-29 Added schematic and electronic elements libraries
2019-12-29 Schematic Plot reviewed
2019-12-29 Added PDF schematic
2019-12-29 More description about schematic
2019-12-29 Diodes description changed
2020-01-19 Added header to unused pins of STM32
2020-01-19 ADDED PCB & 3D visualisations of PCB
2020-01-20 ADDED BOM IN CSV
2020-01-21 modified BOM list name from SiModeM_v2 to M17_ANL_v2.csv & changed schematic description
2020-01-21 Added information about R25 and R26 with no value yet
2020-01-24 added choke for radio part of M17_ANL_v2 added choke of input and output of the voltage regulator
2020-01-24 Added Testpoint description and ICs list
2020-01-24 Added more description
2020-01-24 more changes
2020-01-24 more changed in README
2020-01-24 a lot more description
2020-01-24 Plotted new PDF of schematic
2020-01-25 New shots of 3D pcb design
2020-01-26 Readme header description added
2020-02-08 Added information about testing
